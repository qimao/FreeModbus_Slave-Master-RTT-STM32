# IAR project FreeModbus_Slave&Master+RTT+STM32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VB ST STM32F103VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\APP\inc; ..\BSP\inc; ..\Libaries\STM32F10x_StdPeriph_Driver\inc; ..\RT-Thread-1.2.2\include; ..\RT-Thread-1.2.2\components\drivers\include; ..\RT-Thread-1.2.2\components\drivers\include\drivers; ..\Libaries\CMSIS_EWARM\Include; ..\Libaries\CMSIS_EWARM\CM3\DeviceSupport\ST\STM32F10x; ..\FreeModbus\modbus\include; ..\FreeModbus\modbus\rtu; ..\FreeModbus\port
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FreeModbus_Slaver&Master+RTT+STM32.srec
  ILINK.IlinkOutputFile: FreeModbus_Slaver&Master+RTT+STM32.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/src/: app.c app_task.c stm32f10x_it.c
    ../APP/inc/: stm32f10x_conf.h
  group BSP
    ../BSP/src/: bsp.c gpio.c usart.c
    ../RT-Thread-1.2.2/libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group CMSIS
    ../Libaries/CMSIS_EWARM/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group FreeModbusMaster/Modbus
    ../FreeModbus/modbus/: mb_m.c
    ../FreeModbus/modbus/functions/: mbfunccoils_m.c mbfuncdisc_m.c mbfuncholding_m.c mbfuncinput_m.c
    ../FreeModbus/modbus/rtu/: mbrtu_m.c
  group FreeModbusMaster/Port
    ../FreeModbus/port/rtt/: portevent_m.c portserial_m.c porttimer_m.c
    ../FreeModbus/port/: user_mb_app_m.c
  group FreeModbusSlave/Modbus
    ../FreeModbus/modbus/: mb.c
    ../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group FreeModbusSlave/Port
    ../FreeModbus/port/rtt/: port.c portevent.c portserial.c porttimer.c
    ../FreeModbus/port/: user_mb_app.c
  group RT-Thread/Drivers
    ../RT-Thread-1.2.2/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c wrokqueue.c
    ../RT-Thread-1.2.2/components/drivers/misc/: pin.c
    ../RT-Thread-1.2.2/components/drivers/serial/: serial.c
  group RT-Thread/Kernel
    ../RT-Thread-1.2.2/src/: clock.c cpuusage.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c module.h object.c scheduler.c slab.c thread.c timer.c
  group StdPeriph_Driver
    ../Libaries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libaries/CMSIS_EWARM/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
